Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: Tue Aug 11 14:04:47 2020
Author: at3107
Written by: PTC Creo 1.0
Made in: PTC

# IfcProject, Default Project
LongName: Project Status; Phase: Project Status

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Part, EE461
In: Default Storey
PTC_Identity Data - DEVICENAME: Cable Temperature Sensor; MEASURAND1: Temperature; Measuring range -30...+105 °C (-22...+221 °F); OUTPUT1: Passive T-Sensor; ENCLOSUREMATERIAL: Sensor sleeve: stainless steel (1.4571 / 316Ti); Cable: PVC; ENCLOSUREDIMENSIONS1: Cable length: 2-wire connection: up to 10 m (32.8 ft); ENCLOSUREDIMENSIONS2: Cable length: 4-wire connection: up to 10 m (32.8 ft); VOLUME: 2893.19; SURFACE_AREA: 2462.64; MASS: 2893.19; DENSITY: 1; CENTRE_OF_GRAVITY_X: 49.3362; CENTRE_OF_GRAVITY_Y: 13.1841; CENTRE_OF_GRAVITY_Z: 0
